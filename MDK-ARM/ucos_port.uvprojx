# Keil uVision project ucos_port.uvprojx, settings and files
target ucos_port (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: ucos_port +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,ART_ACCELERATOR_ENABLE=0,STM32F767xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\QSPI;..\HARDWARE\W25QXX
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_it.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_utils.c stm32f7xx_ll_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group HARDWARE/QSPI
    ../HARDWARE/QSPI/: qspi.c qspi.h
  group HARDWARE/W25Q256
    ../HARDWARE/W25QXX/: w25qxx.c w25qxx.h
software components: CMSIS:CORE 4.3.0
